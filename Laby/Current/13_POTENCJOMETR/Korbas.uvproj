# Keil uVision project Korbas.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Korbas +hex
  c flags: Optim=1
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s main.c keyboard.c led.c timer.c timer.h timer_interrupts.c timer_interrupts.h servo.c servo.h uart.c uart.h command_decoder.c command_decoder.h string.c string.h potencjometr.c potencjometr.h
